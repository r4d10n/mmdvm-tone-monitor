options:
  parameters:
    generate_options: qt_gui
    id: mmdvm_tone_monitor
    output_language: python
    title: MMDVM Tone Monitor
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    label: Audio Gain
    start: '0'
    step: '.01'
    stop: '1'
    value: '0.99'
  states: {}
- name: decim_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: filter_width
    gain: '3'
    samp_rate: samp_rate * 3
    width: '500'
    win: firdes.WIN_BLACKMAN
  states: {}
- name: decoder_volume
  id: variable_qtgui_range
  parameters:
    label: Audio Volume
    start: '0'
    step: '.01'
    stop: '1'
    value: '0.02'
  states: {}
- name: demod_level
  id: variable_qtgui_range
  parameters:
    label: Demod Level
    start: '0'
    step: '.01'
    stop: '10'
    value: '0.1'
  states: {}
- name: fft_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: filter_width
    gain: '1'
    samp_rate: 'target_samp_rate '
    width: '90'
    win: firdes.WIN_BLACKMAN
  states: {}
- name: filter_width
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: interp_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: filter_width
    gain: sps
    samp_rate: samp_rate * 3
    width: '90'
    win: firdes.WIN_BLACKMAN
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '.01'
    stop: '1'
    value: '0.8'
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    label: RX Frequency
    start: 70e6
    step: 100e3
    stop: 440e6
    value: 435.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '125'
  states: {}
- name: target_samp_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.01'
    gate: 'True'
    ramp: '0'
    threshold: '-140'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: float(target_samp_rate)/(4*pi* float(filter_width))
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: target_samp_rate*2
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: demod_level
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: decoder_volume
    type: float
  states: {}
- name: dsd_block_ff_0
  id: dsd_block_ff
  parameters:
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    mod: dsd.dsd_MOD_AUTO_SELECT
    uvquality: '3'
    verbosity: '2'
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: fft_filter_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100'
    decim: '1'
    gain: '1'
    samp_rate: target_samp_rate * 2
    type: fir_filter_fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: target_samp_rate * 2
    type: float
  states: {}
- name: rational_resampler_base_xxx_0_0
  id: rational_resampler_base_xxx
  parameters:
    decim: sps
    interp: '3'
    taps: decim_taps
    type: ccc
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    taps: ''
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: rx_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [dsd_block_ff_0, '0', rational_resampler_xxx_0_0, '0']
- [fft_filter_xxx_0_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_base_xxx_0_0, '0', fft_filter_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', dsd_block_ff_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [rational_resampler_xxx_0_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_base_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-356-g47f495e4
